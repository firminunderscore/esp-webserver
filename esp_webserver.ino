#include <WiFi.h>
#include <time.h>

const char *ssid = "SSID";
const char *password = "PASSWORD";

WiFiServer server(80);

const char *ntpServer = "pool.ntp.org";
const long gmtOffset_sec = 3600;
const int daylightOffset_sec = 3600;

IPAddress local_IP(192, 168, 1, 250);
IPAddress gateway(192, 168, 1, 254);
IPAddress subnet(255, 255, 255, 0);
IPAddress primaryDNS(192, 168, 1, 200);

void setup()
{
  Serial.begin(115200);

  if (!WiFi.config(local_IP, gateway, subnet, primaryDNS))
  {
    Serial.println("Error: IP Config");
  }

  Serial.print("Wi-Fi connecting... ");
  Serial.println(ssid);
  WiFi.begin(ssid, password);
  while (WiFi.status() != WL_CONNECTED)
  {
    delay(500);
    Serial.print(".");
  }

  Serial.println("\nWiFi connected.");
  Serial.println("IP: ");
  Serial.println(WiFi.localIP());

  configTime(gmtOffset_sec, daylightOffset_sec, ntpServer);
  Serial.println("NTP sync...");

  server.begin();
}

String getCurrentTime()
{
  struct tm timeinfo;
  if (!getLocalTime(&timeinfo))
  {
    return "Error : can't get current time !";
  }
  char timeStr[64];
  strftime(timeStr, sizeof(timeStr), "%Y-%m-%d %H:%M:%S", &timeinfo);
  return String(timeStr);
}

void loop()
{
  WiFiClient client = server.available();

  if (client)
  {
    String currentLine = "";

    while (client.connected())
    {
      if (client.available())
      {
        char c = client.read();
        Serial.write(c);

        if (c == '\n' && currentLine.length() == 0)
        {
          String currentTime = getCurrentTime();

          client.println("HTTP/1.1 200 OK");
          client.println("Content-type:text/html");
          client.println("Connection: close");
          client.println();
          client.println("<!DOCTYPE html><html>");
          client.println("<head><title>Your're connected to a random ESP32</title></head>");
          client.println("<body><h1>Yeah, this webserver is a fucking ESP32</h1>");
          client.println("<img src=\"data:image/jpeg;base64,/9j/4AAQSkZJRgABAQEASABIAAD/4QRCRXhpZgAATU0AKgAAAAgAEwEAAAMAAAABD6AAAAEBAAMAAAABC7gAAAEOAAIAAAABAAAAAAEPAAIAAAAIAAAA8gEQAAIAAAAOAAAA+gEaAAUAAAABAAABCAEbAAUAAAABAAABEAEoAAMAAAABAAIAAAExAAIAAAARAAABGAEyAAIAAAAUAAABKgITAAMAAAABAAIAAAIgAAQAAAABAAAAAAIhAAQAAAABAAAAAAIiAAQAAAABAAAAAAIjAAQAAAABAAAAAAIkAAQAAAABAAAAAAIlAAIAAAABAAAAAIdpAAQAAAABAAABPoglAAQAAAABAAADSgAAAABzYW1zdW5nAEdhbGF4eSBBMzQgNUcAAAAASAAAAAEAAABIAAAAAXBhaW50Lm5ldCA1LjAuMTMAADIwMjQ6MTI6MTQgMjE6Mjg6MzMAACCCmgAFAAAAAQAAAsSCnQAFAAAAAQAAAsyIIgADAAAAAQACAACIJwADAAAAAQAyAACIMAADAAAAAQAAAACIMgAEAAAAAQAAAACQAAAHAAAABDAyMjCQAwACAAAAFAAAAtSQBAACAAAAFAAAAuiRAQAHAAAABAECAwCSAQAKAAAAAQAAAvySAgAFAAAAAQAAAwSSAwAKAAAAAQAAAwySBAAKAAAAAQAAAxSSBQAFAAAAAQAAAxySBwADAAAAAQACAACSCAADAAAAAQD/AACSCQADAAAAAQAZAACSCgAFAAAAAQAAAySSkAACAAAABDA3NQCSkQACAAAABDA3NQCSkgACAAAABDA3NQCgAAAHAAAABDAxMDCgAQADAAAAAQABAACgAgAEAAAAAQAAD6CgAwAEAAAAAQAAC7igBQAEAAAAAQAAAyykAgADAAAAAQAAAACkAwADAAAAAQAAAACkBAAFAAAAAQAAA0CkBQADAAAAAQAZAACkBgADAAAAAQAAAAAAAAAAAJiG4DuaygAAAAcIAAAD6DIwMjQ6MTI6MTQgMjE6Mjg6MzMAMjAyNDoxMjoxNCAyMToyODozMwAAABn0AAAD6AAABwgAAAPoAAAAGAAAAAoAAAAAAAAACgAAAKkAAABkAAASKgAAA+gAAQACAAcAAAAEMDEwMAAAAAAAAAAAAQ0AAABkAAAACgAAAAEAAAAEAgIAAAABAAIAAAACTgAAAAACAAUAAAADAAADyAADAAIAAAACRQAAAAAEAAUAAAADAAAD4AAFAAEAAAABAAAAAAAGAAUAAAABAAAD+AAHAAUAAAADAAAEAAAbAAcAAAAUAAAEGAAdAAIAAAALAAAELAAAAAAAAAAuAAAAAQAAADsAAAABAAMY5QAAJxAAAAADAAAAAQAAAAoAAAABAAjaWAAAJxAAAADkAAAAAQAAABQAAAABAAAAHAAAAAEAAAASAAAAAVVOSUNPREUAAEMARQBMAEwASQBEMjAyNDoxMjoxNAAAAAD/2wBDACAWGBwYFCAcGhwkIiAmMFA0MCwsMGJGSjpQdGZ6eHJmcG6AkLicgIiuim5woNqirr7EztDOfJri8uDI8LjKzsb/2wBDASIkJDAqMF40NF7GhHCExsbGxsbGxsbGxsbGxsbGxsbGxsbGxsbGxsbGxsbGxsbGxsbGxsbGxsbGxsbGxsbGxsb/wAARCAESAZADASIAAhEBAxEB/8QAHwAAAQUBAQEBAQEAAAAAAAAAAAECAwQFBgcICQoL/8QAtRAAAgEDAwIEAwUFBAQAAAF9AQIDAAQRBRIhMUEGE1FhByJxFDKBkaEII0KxwRVS0fAkM2JyggkKFhcYGRolJicoKSo0NTY3ODk6Q0RFRkdISUpTVFVWV1hZWmNkZWZnaGlqc3R1dnd4eXqDhIWGh4iJipKTlJWWl5iZmqKjpKWmp6ipqrKztLW2t7i5usLDxMXGx8jJytLT1NXW19jZ2uHi4+Tl5ufo6erx8vP09fb3+Pn6/8QAHwEAAwEBAQEBAQEBAQAAAAAAAAECAwQFBgcICQoL/8QAtREAAgECBAQDBAcFBAQAAQJ3AAECAxEEBSExBhJBUQdhcRMiMoEIFEKRobHBCSMzUvAVYnLRChYkNOEl8RcYGRomJygpKjU2Nzg5OkNERUZHSElKU1RVVldYWVpjZGVmZ2hpanN0dXZ3eHl6goOEhYaHiImKkpOUlZaXmJmaoqOkpaanqKmqsrO0tba3uLm6wsPExcbHyMnK0tPU1dbX2Nna4uPk5ebn6Onq8vP09fb3+Pn6/9oADAMBAAIRAxEAPwDNpKfSUgExxUchCqc856CnSSCMY6t6VWZixyetAD4yWZh3ZSKip6NtdW9DTWGGI9DTASijGaKACiiigAooooAKKKKAAY70UUUAFFFFABS9sUlFABRRRQAUUUtABRRRQAUUUUAFFFFABRRRQAUhpaQ0ALRRRQAUUUUAFFFFABRRRQAUUUlABRSUUALmiiigAoxTgKXGDg0AXsfrUEs2z5UPzdz6UT3GQUj6d29arUgAnJz3pQCTwMmlVGbO0Zx1p+VjAK53YwaYCNtVSoOc85qNjk59ac2OvrTe1ACUUUUAFFFFABRRRQAUdvelGO9JQAUcUdqKACiiigAooooAKWiigAooooAKKKKACiiigAooooAKKKKACkNLQelACUtIKWgAooooAKKKKACiikoAKBQBS0AJijFOzSUAFOVcnFCjNPJ2jGKAEztHamscntSE5pM0AFOVC2cEcetORN2dxKjGRx1okc5GB2xxQAruqkBFxxzimtjHPWkJGPemUABNKOhpKBQAUUUUAFFFFABRRRQAUUUUAFFFFABRRS0AJS0UUAFFFFABRRRQAUUUUAFFFFABRRRQAUUUUAFB6UUHpQAgpaQUtABRRRQAUmaM0UAFLiiloAKKKKACkpaKADocijOaVVLHihgM4oAaT6UgoxS0ASSOxIGaazce9IW4wKbQAUUUUAFFFFABRRRQAUUUUAFFFFABRRRQAUUUtABRRRQAUUUUAFFFFABRRRQAUUUUAFFFFABRRRQAUUUUAFHako7UAApabSg0ALSGloxQAgFOoxRQAUUUUAJS0tGOfSgBKeqcZPSgKBy1DvkYFACM2DgdKbSUUAFFLSUAJRRRQAUUUUAFFFFAB2oop8aF2x270AMoqWZFTAHWoqACiiigAoopaACiiigAooooAKKKKACiiigAooooAKKKKACiiigAooooAKcqZAZuFJ496fDFucBzgd/YVdMaxv5DAywsflI+8Ce4oAp5HTAxUbpgZHSrP2VzdGBCHYHGR0+tNlieCQow5HfsaAKtFSPH/Eo47io+p4oAdtPWip/s8gi3MOM9KjZSvUUANpKWigBKKXHHWlVckCgBAM9BUm0IMtyfSl+WMAggt/KomYmgBXct17UyiigApaSloAKKSloAbRRRQAUUUUAFFFFACgEnAqe36Mfeq9TQnCv7c0AMlbdIfbimUtJQAUUtLigBKKXFLgUANop2KMUANopcUYoASiiigAooooAKKWigAopKKAFpKKUAscAc0AJ3wOtWLeJfMXzAWGeQtPs44/OHmJvHfnGKl+zlZG2t5ca/efsPQfX2oARrZ1uFSBmzycnsPU0+W6KrsVy7AYMuMceg9vfvTZrgtEUi3CNRzu5Zvc/5wKYVyibMsGGeO5oAaiyRuTE5BXOdvUCrbTRXcOGG1xk98J75/pUXkMFWZsx7c73Pf0A96qTP+8OFA9hQAOwRjtbdjoQMZpIiUlV9qnnoe9NIPU9xT1Xkd/oetAGvBIssOWI2+ncH0qjdRpk4bDddpGOfao4pGjbIPB7D0q3GVmBKr14Iz0pAZrKQaQg8VfubY4Dr8w9h0qFIGf5jnHX60wIFUtwBT2ZYz8qjPrRI4QFI+Bxz61ASSST1NAAST1pKKKACiiigAoopaAEpaKKAG0UUUAFFGKKACilA7mkoAKcDgEeoxTacASMgUAIBlgPWpHVAcLnNNAx9aKADFFFFABRRRQAUUUUAFFFFABRj0opaAG0UpFJQAUUUUAFFGaVV3cnp6etACAbjirtmqFyuwHK4z3B9aS2aNUdX2AEdT1FSCJbeQzSZDH7kQOMj1PoPbvQAfZ41Akd2SMdcdXP+z/U9KimlMuABtjX7qjoP/r+9LJI0r75DljwPb2ApIpVUnfAroTg54K/T0oAmslDy7fN2fh1qZLV4Lg4Z+OSiHlqrNBJG6MilgzYGOuamJ8tH8x3dpDtkZDjH09aAILyeVpRgj5cgBeQvtUBgeNgHAyecVdfHDx7cRjaxBwD9KhuGbady5U9DjpQA24EG/wDck7PRuoqFj8ox07mpEUBiHxs9j3pywyGJphgKh2nHXP0pDIwcrwPxqSJmiYMp59KYAAcDp6EVMiBPnk6E/dHU0CNCFUkt98jFQDnAP3qo6hcl3VEICqOFUdKRpZXBMakkDoB0rPZizFick0AKTk80lJmjNMBaKKWgBKKKKAClpKWgAooooAbiloooAKSlooASiilxQAlSKdo46mmgUtABRRRQAUUqgscKCx9AM1ai027l6RbR6ucUAVKK14tEJ5mmx7IKuRaXaR/8s959XOaAOeRWc4RSx9FGakltp4UV5Y2RWOATXTqioMIoUewqDUYRNZSKSAQNwz6igDmaKX3pKAFooooASgjvS0e1ADaKKk8tkUMynkZHFACIhxuIOKu20iNEYmIyzZC7ctn29afayCWIRIxLrllUrwPqfSo9yW6lIGy54aXoT7L6D3oAXalu5bCtPnOOqx/4n+VRltzgyPgseWP8zTMgEdhVqeyCwpIjK7Fd2Ackr64oEJG0dvOrECeEjcHTrj+n0pswFwTNAhTk7lPTHbnuabauAwQQ+aHOAB29frV2ES2JmhjlRyR8qnsPU+n0oGMtP9GgEksjMJFCxoOePX2ppjdN07JtcOPLKnIwOvFEkvkFmPzyuBlG6L9f8KrNcyt1cnnOf89vagRcEggCvIqvls4xgNnvj2qKSPAEsbeYshxz/F7H39u1VndpGLuSW75qS3m8s7W+aNuCvXHP+eO9AyYQxLab4jyTht3JX0qsd0RMQY4PXFWpYyDlDuznvyfX8f0qB0VEHltnPLE9V9vpSAYG8vspbHcdKktrYzlmYn6/5/lTIEjZwZpPLTG7J6t9PWpmvGTIgiVV/h3ckUANmkeH/R1+VGG5iOGI9DVSeME/Ljd7d6t2yxPI7XDO7HnA6sajnhMTlchgO47ex96YFCkqd49/I+9/OoaAAGlpKUUAFFLSUAFFFLQAUUUUAJRS0UAFIeaKKAClpKKAHDpRR2FFABUkRVZY2kXMe7nPQjvRbxedOkWdu84z6VsataKunr5a4EP8qANCOONFAjRVHbAxT6q6ZN59jGSfmX5T+FWiMjB6UAV3vbeM7TKGb+6vzH9Kb9pmk/1Nq+P70h2j/GrEcUcYxGiqPYYokkSMZkdVHqTigRX8q8k+/OsQ9I15/M0f2fA3+t3yk93YmmS6taR5w5kPog/rVOXW3P8AqYVX3Y5oGZs0ZhmeJuqHFMqSeZ7iUySEFj1wMU1EaQ4jVnP+yM0ANoq7FpV3J1QRj1c1di0RBzNMzeyjFAGLR3wOtXdQtY4rpY7Y5BHIznBqB4pICQyEbThs+tADTE0QyyEHryKvwnz7U/vGAX5SWHCA/wA/pSKFmtwZd6xDjcfvN7D/ABqKWYMAqjZGv3UHb/E+9AA7qqeVCCsY6+re5/wqNEaV9qDJ7n0pY0M0mwMF6nNaAaO2i2x4HdnPOP8AE0AZssZikKSDBH6061CG5QOhKscZHUUssnnH0QHIz1J9aYF4znHp70AaSNGZ5fs29HcADdjJUdx7+1VZJVhAVDulXIMnXH+JpYpkZWaYHzMZyBy2O/saYoM8kkrKgRTucA449vU0CIDnv35+tKvFLJGYyMHch+63r/8AXptAxffPTvUkDBZRjaCxxuJ+79PT60xQWYKoJY9AKkaE71jUh3Iy2Og98+lAFsGVFcuihyuWJ5O0Hueze/ekT7PclmT5FU8buPxPpVSSSXb5MjNhDjae1RFVJ5AzQBNO6zyARg7V/iP+HpTQeOB/9f604LlFkUYx1Xp/+upYYEeMuJCMH5iRwP8AGgCHGUDL8jp1OcD657Ux5naPYT8vUj+8fU+pqw7xBCuzI5Cr3J/vE/yFRRw7l8yQ7IhxkdWPotAFbPtSOm/kfe/nU89vsUSxlmiJ6nqp9D70yGJpWO3gdzQBVxS0+YATOAcgHqKZQAUUtJQAUUUtABRRRQAUlFFABRS0UAJRRS0AOH3RSUqY2NxyOaKAFVijB16qciupG26tfVZE/nXK1vaJNvtDGTzGcfhQBW0VzFcTWz9ev4jg1s1iX+bPVknA+VvmP8jU7ayZDttbZnPqf/rUALrMlxCI2ilZUbIIHrWKxLNliWPqTmrV5e3M+Yp8LtOSoGMGqlABSrt3DcSFyMkelJRQB0cOmWkYBEe/3c5qZ57e2GHkjjHpmuca6uHQI0z7QMAA4qH3oA3pdat1/wBWryH1xgVVGpXd24jhVI93Ax1P41Rt7dp2I4BAJAJ61IqNFMmV3lhkKDyfb60ANYPGd0inBJHJxz/nvV0AShPPXBxkRk8sPVvQfzpQo35O0zDqCchD7+p/QUYzzwW7k8kn60ARSyfv1Fyp29ivAA9vakuIAF82IYX+JM52H69wfWpXRZE2MeOoPdTUUG5JfLJYOvGM8MvtRcCuMg5U4PYinPI8pBc59gMD8qeFjil+dTJD0z3H/wBcUksJidcHerco4/iFADTwefwxQeD8w5POPSnMrpgkHn+I/wAhWink3eneSoCyj7rHru9KAGRwQ3On5Qfv1Gc9Pz/wrMIIJDKVYHkEcirFsJYJt5A+U8rnIP5VMwjvZMMDDcOMpuxsb2oArRMMGJlZkY5AUZIPqP8APemFQsm0MCM4yKtPssmEbbhkkOwOGP09BUklo0zsQ4DYBzj5XHrx3/nQNEccZ5jhYejy9R9F9fUU/CRfuiqqh5DnJy3P3/8APFTRFbdhBJE6DOVLc5Pr6CmyBLeJN7Aqw6L/AMtD7e3vSHa5DPb7IcSvlkXhyMc/3Pf29Kpj0JqRnkuLhF2bnztWPoFHpS3MUcU7JCzMo4y3X3FMViwt1GbTa65ZAAo9/wDCondPJVVZmPUYBAT2x61AMf0/Gp2xa4Mi7psZWPqF92/woEIFWNRJcZ2tykf8T+/sKdDP5s5ZtpZeFQjgD0AqOOYvHIzFXkfrvxnHqKBAgBllIWP3/ipASRBlldhgQ4w4boR6VVnuRt8qAkRjqe5pLmczKAo2RDgD1qvQAUUUUwEpaKKAEpaKKACiiigApKWigAopKKAFpKKWgBVOD9eDS02nLyMd+1ABV/RpvLvthPEgx+NUKcrFGDIcMDkEdqAOomt4ZtpmRW29N1Vrq/t7WFlhZDJ0Cr2rCkllmOZZHf6moxQArEsxZjlick+tJS0UAJRS0gBJwOTQAVYgtjIrvkFkGQuev0p0VruhLq4LZwV749afAkvmssZTah+Z2HCigBIUkW5EaKsj4yMHge+e2KtqFw3lyDzDwZB/JfQe9L8pB8vKgn5srgt9fb2p3U5/nQAn1GO2AKU8+3vUkYQ/Kw69DTSpViCc+mO9IBu0Adf1qOWISADOGXlWHY1J6/rSr1AOaAKynzQYnUoy/fUfzFRrJ5O6J18yFjle3PqDVu5hEoV422zL0bHB9jUC4mTy2BTafmTqVP8AhRcC3BKLyxFs4AdcAEcHPrWesbxSMpYhh8px3qWyVBdAO5U4PlMDgMfrSvCyL8zMZAfmJ9aaAYMgccEU7arrs42nnPTafWmZ3A9eBzgZq3YlY4jI0eHJypbpj1psaHvMIooTcj9+yMpbaCSvbI96ktJEUGReYgoC/wCz6596qSRLcP5pYKxbD4yQfeppFynlyDZFkAFf4D2+oNS2VFEzwNfSLMjEhfujHHvUUkLowQRbXRi4U8huOR7Ves2FsHQgBB09qq394JjiPgdCfWpNo3bsloUZJyZ5JYl8sMMDPLY7/TNQHc7hI13MeAoqRVaVisYyepJ4Cj1JpGlEA2QKSG+/KeC/sPQVSMpLUJGFpkoQ8/Tf2T6ep96dCwaAAuuG5bcOQR/PmgyHYMJ8p44/lTTttU8xl3P/AAp6UEvQAiQ5mmAwSSE9arz3DyOHfGB91Oo+tNllcsWkbMh4x2UVCTk5559aCQY5bOc0lFFMAooooAKKKKACiiigAooooAKKKKACiiigAooooAKKKKAHAhuvB9aUgg4PFNxTlcgYOCvoaACkpw2t0O0+ho2N/dz9OaAEoo9qVVLfSgBAC3T86tx2qtEpRwSThhjkU42yKiskmU25J29D6VLbxyJGHl3dMrF0J9yewoAZbRScliViBxkDJY+iirIGdhXKKOiDoD6+596eqZbcSc4xjGAB6Adqdt4zg0gGYHSl479KUjtS7ePegBXjCgEHIPenLiRdrn5uxpqNjIPzCgpt59O4oAYVYHBBz70lTZDrzwRyTULA59/agBRzxjHvUc8RciSPAkAwP9oehp3TpTt2Oh+gFAFbCXMXJKqvUHkqf8KmgnM4EMpHnqPlZuBIB2Pv702aIuTNEP3mMMvTeKYwW6TJbCgcEgHB9DQmBJPcLCrRwFN5++6jj6L/AI022nSTEU6gtjCE8BvRTVLJ6N1FLgH3pgajJJsOI9xz8pAAx7EVXFy8SvGBmTd98HIH096jNzI8ezABxgvn5iPQmowABwDSsNMeHKqRuJzyee9ORDLnkJGvDSHoP8T7UkcW5RJISsXbHVz6L/jUck7tKqsoijXOxR0X39zRY053YWebaViQMkKsD7ufU/4UrSPPtG4OVXauBTnL3R5IYnrjoBUUsu1DHbDgjmU8ce1BDYrOIFKRjfMTjI6LVQuU3DduZjlmBppfChELbepyepptAgpKWkpiCiiigAoIIODR0OaCcnJoAKKKKACiiigAooooAOMDjnvRRRQAUUUUAFFGKdjFACAUtFFACUtFH1oAKM45BIpKmt0jM6iUnb329aAETc+FdjtJqzcQKuTGS6Z+Xjk+xpWtXOBENzFsDAxx/nvUoZbZflcu/Qyensv+NAD4IfKIMgLy5HydVT6+p9qsLHgliSSxydxzk1XsJ1DFHAAJ+Uk1eYdfWkBHilByMHH1PalxSYoARlKHHX+tMJOO1Sj5htb+dMPyPyoPsaAAKSrEgjC7hSKcjaT06A053OzAXanTjnNNcbUTIw3NACuuGBX17U4jzweQGUdaFGW3ZOVGTSsPQ5wMgk5oAh6E5BBpMZOB17U+Ug9AQeO9MA9OPTNAAsisxWOUMykZA7f402eBhmWNclhiSMfxe496WKFd5aNcE8kiriIxGIxn1J4pNjRl7knP73gAH5x/DnoT6ioXWSKQxyDDD07+9XbuAKfOjwqqPmbP3vU4psiKtqEfdu4MSkfMo7g+3oKaYiop4ySMVOECKJJUZsj5Ih1b3PoKCot+TH5s46L/AAp7t7+1RQXDrI7PIyzMTkkZ/CmAn2iQ3W+VtjgDaMcL7D2qR085izEbc7mbsDQ8aDDu+IkGAx7/AEqvcyO4w4McQ6L3NIY64lJXy4spFjlz/FVNnBICghB0BOaUtk89Owz0qMdaYD6KKKBBRRRQAlFLRQAlFFFABRRRQAUUUUAFFLSUAFFFKBQAlKBS8CigAooooAKKKKACiiigCe1WMlt4OSMAjsatS2LZjOAny7mfoAPU1nq205q/PMWjjULiPAZV6/ifU0ALJOqoUiztP3ier/X0HtVc/NliwznGKbnJpQO5piHxIW3EMqlRnnvWlaTiVNjcMOme9ZROenSpVAEYkEgDhsBe/wBaTGazfrSdOTTLWcXCc4DjqPX3qQjufypAMOfpSkmQAfxDnJ9KUjim989OaAAF4yQGx7Uw5JJY5NWCoKg7ct7GmvFgbskjvmgCMHoTkEdCOtDNnhFCg9T60cd6AmT26UAIQfSnJFvUHOCOpqQJuUbj8vb3/wA+tSRhSMuuE6AAdfYUmx2GqhOQigIOSx/z1pZZQAqbQqHhUzgsfelkk3SCI7MnomeAO5PvVZ5DiW3ZFkY8l+2OxJ7YpLUBzyGCYo0YlLjEYQZ+o/8Ar1Rd2hyIR5kx+9IOQnsuep96SadkjIg3ux+/KRyw9vQUQShljQyMqrzsC559jVbB6jbaRRGyF2XPXP8AEP8AGnOiq/mzdWIVV7tQSsD5KhpmJKpngVSld/MEkjBpOw7LQIW4kd23TYwD8sYPFQFiST3PWjPWkpgApvenCmnrQA+iijFABRRiigApKWigApKWigApKKKACiiloAM0lFLQAoGKWiigAoooxQAlFFFABRR1ooAKKKKACpoJFCmKUnaeVP8AdNQ0lAFnp1pDzTYm3DZ/EOnv7U4HA6c0xDxtUZIJPoabnPJpACTxyaU47UASRStE4ZeorXjkWZMggkdQDWKoBYBiVU9SO1WklSK4JhyEzgZOBSaA0SM00j8qkUhxkHIpGHrSGOiwUA7jjmlf7jBulRFcmgsTwOaQDcY+b8gakROm/tyF9vf/AApyx4GerD15x/8AX/lU3yqv8JfGTu6L9aTYxoUEAyDcx6KO/wDgKjMnmyFA6b1H3uoUdsU1mMySGFkyOCxPLHuPpVeWUXHluqGNVG0bfvN6qvt70JAI8m+IoVVGjPzSjoD7epPpVG7lcfu0RhECC27qx9W/wpZpZPNAdQqJwka9B6n6+9PJe6fJO5j1bFUIUSmVFVSTxxxj8/amllt0KRbWmA5JP3abLMI0aO3ZR2Zyf5VSYgAqpOD1Y/xUAK7Yzgh3b7z/AOFRijvmjvTASilooASmnrTqRutAD93oKXcaaOlFADg/qAaXch6qR9KZRQA8oD905phGKM4p+dw560AMopSMUlABRRRQAUlLQaAEoopaAHUU7ypCcBGP4UvkycfIeelAEdLn8KeYZQOY2xQIZCOEY/hQBH9KKkEMp6IeuKPIl/55tn0oAjoqT7PN18tvSgwTd42/KgCOjqakMEw6xN+VH2eY9Im546UAR0VKbadRkxkdqX7LP/zyagCH8anVvMXP8Y+8PX3pv2af/nk3+FCQXAIZI2yOhxQA8nqB0/nQoJPFOkjZQGKFQf500njA4Hf3piHAAnA596OgFIoJ57DrS4+UHsTQBas7nyjtbpWn1AYYIPesLpzWhY3JPyMcn1NS0MtkE4UDOegpSUiUMSPqP6f40PIsEas3zb/4e7f/AFvaovL5+03TAL1C5walsaRbJVFLIy+m7oB7D3qtLIPIE6eWYgc7SeWX1J9aWaQwNFM4UoePLUdD2x61TmkCOzuo8wncIuqofVvf2oSC4+5lVn81kI3LxGOC49W9BVAXEouhLIwDYwpAyF9gPSnRzTK0jlisjjlm5Jp6xJ5aySkCNB1/wqhChXuCWlcYByz9KgnuVZfKgYJH3Pc06cy3KqI1IgPQKOtVzbXGcGF+O2KAIiTjb/D1FNqX7PMRny2o+zzEA+W3PTimBHRUotpiMiJqb5Ev/PNuOelADKKk8iYEfu2/KkaGRRkowFAEdI3WlIIOCCD6GkagBy9KKB92igAoopR70AJRRxRQA7qtNpykA802gAooooAKKKKAEpaKKAH+dN/fNBllOPnbiiigA86b/no350edN/z0b86MUYoAXz5/+ejUv2if/no1NxSYoAcZ5z1kagzzHrI3502jFAD/ALRPjHmtij7TP/z1bimYpKAJBcTj/lq350fabjp5r1HRQBILi4wR5r4PXmgXNwvSVhTKKAJBcy7v3jF06FTUmBkHPynkEVXqSJwp2vyhPOO3vQBIWzjjAHanLlhjPyj17U3bh8H9PSlLZ4HA7CmID1pRkc8ihV43N07e9TRRvOwyCR0VRQBet7gSyBpIV37QqY6MfepJJHguCGAmMi4QKOmOo+nvVdSRmG3IZyPnf+FR7f41DLLtQrG5bPDyHq3t7CpsO4kkjRLtiIaUcBhyIx6L/jUEUzmFogQAT82R1981Ir7tilsKDnAHIPtTjst8u4BkY5VaAEZEiBmmOR0Ud2qrczNK/wAxGB91R0FNkkaVy0kmTg4wOBUOMe9MB/nSqNiyttHTFKbq4PWZ6YKKAH/arjj963FBubg9ZWplJQBIbicrtMrYo+0z5z5relR0YoAkFzOBgSNSm6uCOZCc1HknGe3SkoAJHaRstyaYeaf3qM9aAJO1JQpzxRQAUUtAGTQAlFPwvrRhfWgBlFP2r60jLtOM5oAbRRRQAUUUUAFFFFADhRRRQAUUUUAFFFFMAooooAKSiikAtFFFABRRRQAUo6iiigCYf6lPqaVetFFMRK/+vI/2sVcPFjORwdyjI9PSiikBBcfLpkOON0+Gx3+tTXPFxFjvEM/rRRQxkViMkn2FZ85JeUkknceT9aKKEAmKUAelFFACUvaiimA0UuOaKKQBijHAoooAMUh6UUUAMNMPWiigB0f36cetFFABQKKKACkoooAWlPb6UUUANooooAKKKKACiiigD//Z\"");
          client.println("<br><p>Current time (Europe/Paris) : " + currentTime + "</p>");
          client.println("<p>Read more about it <a href=\"https://github.com/firminunderscore/esp-webserver/\">here</a>\.</p>");
          client.println("</body></html>");
          client.println();
          break;
        }

        if (c == '\n')
        {
          currentLine = "";
        }
        else if (c != '\r')
        {
          currentLine += c;
        }
      }
    }

    client.stop();
  }
}